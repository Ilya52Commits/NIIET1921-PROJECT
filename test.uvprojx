# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: K1921VK035 Generic
  pack: NIIET.K1921VK035_DFP.2.0.5
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  AfterMake: d:\LVOV\SRECORD\bin\srec_cat.exe "d:\LVOV\KEIL\NIIET\TEST [01.01.01]\Objects\test.hex" -Intel -o "d:\LVOV\KEIL\NIIET\TEST [01.01.01]\Objects\test.bin" -Binary
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: RETARGET, RETARGET_USE_UART, SYSCLK_PLL, CKO_NONE, OSECLK_VAL=16000000
  c include: .\bsp;.\CMSIS;.\retarget;.\src;.\startup;.\periph
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group startup
    ./startup/: system_K1921VK035.c startup_K1921VK035.s
  group src
    ./src/: main.c Processor.c VK035_it.c fw_updater.c update_flash_fw.c
  group periph
    ./periph/: plib035_adc.c plib035_can.c plib035_dma.c plib035_ecap.c plib035_gpio.c plib035_i2c.c plib035_mflash.c plib035_pmu.c plib035_pwm.c plib035_qep.c plib035_rcu.c plib035_spi.c plib035_tmr.c plib035_uart.c plib035_wdt.c
  group Modbus
    ./Modbus/: mb.c mbascii.c mbcrc.c mbdefs.c mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbrtu.c mbtcp.c mbutils.c portevent.c portother.c portserial.c porttimer.c
